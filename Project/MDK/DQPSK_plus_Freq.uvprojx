# Keil uVision project DQPSK_plus_Freq.uvprojx, settings and files
target APM32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QPSK_plus_Filter +hex
  AfterMake: fromelf.exe --bin -o ./@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: APM32F40X,APM32F407_MINI
  c include: ..\..\..\..\..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Boards;..\..\Include;..\..\FFT_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ../../../../../Libraries/Device/Geehy/APM32F4xx/Source/arm/: startup_apm32f40x.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_wwdt.c
  group Boards
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: apm32f4xx_int.c main.c ADC_lib.c font_lib.c LCD_lib.c RawDataAnalys.c SignalReceiveHandler.c SPI_lib.c TIM_lib.c UART_lib.c Filter_lib.c WDT_lib.c
    ../../Include/: ADC_lib.h font_lib.h LCD_lib.h RawDataAnalys.h SignalReceiveHandler.h SPI_lib.h TIM_lib.h UART_lib.h Filter_lib.h WDT_lib.h
  group FFT_lib
    ../../FFT_lib/: FFTImplementationCallback.h fftM.h fftM_data.h fftM_initialize.h fftM_terminate.h fftM_types.h rt_nonfinite.h rtGetInf.h rtGetNaN.h rtwtypes.h FFTImplementationCallback.c fftM.c fftM_data.c fftM_initialize.c fftM_terminate.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
